# Keil uVision project 209_Motor_BDC_PID_Location_Incremental.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: R7FA6T2BD Renesas
  pack: Renesas.RA_DFP.5.4.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: 209_Motor_BDC_PID_Location_Incremental +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  c include: .\src;.\src\beep;.\src\debug_uart;.\src\encoder;.\src\gpt;.\src\key;.\src\led;.\src\motor_control;.\src\pid;.\src\protocol
  asm misc: --via=via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group Source Group 1
    ./src/beep/: bsp_beep.c
    ./src/debug_uart/: bsp_debug_uart.c
    ./src/encoder/: bsp_encoder.c
    ./src/gpt/: bsp_gpt_pwm_output.c bsp_gpt_timing.c
    ./src/key/: bsp_key_irq.c
    ./src/led/: bsp_led.c
    ./src/motor_control/: bsp_motor_control.c
    ./src/pid/: bsp_pid.c
    ./src/protocol/: protocol.c
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
