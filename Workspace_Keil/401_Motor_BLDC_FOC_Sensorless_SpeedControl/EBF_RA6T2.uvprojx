# Keil uVision project EBF_RA6T2.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: R7FA6T2BD Renesas
  pack: Renesas.RA_DFP.4.4.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: EBF_RA6T2
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src\application\main;.\src\application\user_interface\ics
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/application/main/: mtr_main.c mtr_main.h r_mtr_control_parameter.h r_mtr_motor_parameter.h
    ./src/application/user_interface/ics/: convert.bat ElfMapConverter.exe ICS2_RA6T2.h ICS2_RA6T2.o ICS2_RA6T2_Built_in.o RA6T2_MCILV1_SPM_LESS_FOC_E2S_V101.rmt RA6T2_MCILV1_SPM_LESS_FOC_E2S_V101_conv.map r_mtr_ics.c r_mtr_ics.h
  group DOC
    ./DOC/: readme.txt
software components: Flex Software:RA Configuration 1.0.0
